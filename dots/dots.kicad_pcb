# Repository Hikakin-0/Dots

## KiCad design dots/dots.kicad_pcb

Parts:
C1, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23: 0.1u; C_0603_1608Metric
C2: 1u; C_0603_1608Metric
C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39: 10u; C_1206_3216Metric
D1, D2: SBD; D_SOD-123
IC1, IC2, IC3, IC4, IC5, IC6, IC7, IC8, IC9, IC10, IC11, IC12, IC13, IC14, IC15, IC16: BD6222HFP-TR; BD6222HFPTR
IC17: NJM7805SDL1-TE1; NJM7805SDL1TE1
J1: Conn_01x02_Pin; JST_VH_B2P-VH-FB-B_1x02_P3.96mm_Vertical
J2: USBCmod
J3: Conn_01x03_Socket; PinHeader_1x03_P2.54mm_Vertical
J4, J5: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
J6: OUTPUT; 32pin smd con
R1: 0; R_0603_1608Metric
R2, R3: 5.1k; C_0603_1608Metric
U1: PGA2350

Connections:
+5V: C3.1, C7.1, D2.2 (A), IC17.3 (VOUT)
+5VD: C4.1, D1.2 (A), J2.1 (VBUS)
BOOTSEL: J4.1, U1.51 (BOOTSEL)
D+: J2.3 (D+), U1.54 (USB_DP)
D-: J2.2 (D-), U1.53 (USB_DM)
FIN1: IC1.3 (FIN), U1.41 (GP39)
FIN2: IC2.3 (FIN), U1.43 (GP41)
FIN3: IC3.3 (FIN), U1.45 (GP43)
FIN4: IC4.3 (FIN), U1.47 (GP45)
FIN5: IC5.3 (FIN), U1.39 (GP37)
FIN6: IC6.3 (FIN), U1.37 (GP35)
FIN7: IC7.3 (FIN), U1.35 (GP33)
FIN8: IC8.3 (FIN), U1.31 (GP30)
FIN9: IC9.3 (FIN), U1.23 (GP22)
FIN10: IC10.3 (FIN), U1.25 (GP24)
FIN11: IC11.3 (FIN), U1.27 (GP26)
FIN12: IC12.3 (FIN), U1.29 (GP28)
FIN13: IC13.3 (FIN), U1.21 (GP20)
FIN14: IC14.3 (FIN), U1.19 (GP18)
FIN15: IC15.3 (FIN), U1.17 (GP17)
FIN16: IC16.3 (FIN), U1.15 (GP15)
GNDA: J3.2, J4.2, J5.2, R1.1, U1.1 (GND), U1.18 (GND), U1.33 (GND), U1.48 (GND)
GNDPWR: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, IC1.4 (GND_1), IC1.8 (GND_2), IC2.4 (GND_1), IC2.8 (GND_2), IC3.4 (GND_1), IC3.8 (GND_2), IC4.4 (GND_1), IC4.8 (GND_2), IC5.4 (GND_1), IC5.8 (GND_2), IC6.4 (GND_1), IC6.8 (GND_2), IC7.4 (GND_1), IC7.8 (GND_2), IC8.4 (GND_1), IC8.8 (GND_2), IC9.4 (GND_1), IC9.8 (GND_2), IC10.4 (GND_1), IC10.8 (GND_2), IC11.4 (GND_1), IC11.8 (GND_2), IC12.4 (GND_1), IC12.8 (GND_2), IC13.4 (GND_1), IC13.8 (GND_2), IC14.4 (GND_1), IC14.8 (GND_2), IC15.4 (GND_1), IC15.8 (GND_2), IC16.4 (GND_1), IC16.8 (GND_2), IC17.2 (GND), J1.1, J2.4 (GND), J2.7 (GND), R1.2, R2.2, R3.2
unnamed: J2.5 (CC1), R3.1
unnamed: J2.6 (CC2), R2.1
OUT1_{IC1}: IC1.2 (OUT1), J6.1
OUT1_{IC2}: IC2.2 (OUT1), J6.3
OUT1_{IC3}: IC3.2 (OUT1), J6.5
OUT1_{IC4}: IC4.2 (OUT1), J6.7
OUT1_{IC5}: IC5.2 (OUT1), J6.9
OUT1_{IC6}: IC6.2 (OUT1), J6.11
OUT1_{IC7}: IC7.2 (OUT1), J6.13
OUT1_{IC8}: IC8.2 (OUT1), J6.15
OUT1_{IC9}: IC9.2 (OUT1), J6.17
OUT1_{IC10}: IC10.2 (OUT1), J6.19
OUT1_{IC11}: IC11.2 (OUT1), J6.21
OUT1_{IC12}: IC12.2 (OUT1), J6.23
OUT1_{IC13}: IC13.2 (OUT1), J6.25
OUT1_{IC14}: IC14.2 (OUT1), J6.27
OUT1_{IC15}: IC15.2 (OUT1), J6.29
OUT1_{IC16}: IC16.2 (OUT1), J6.31
OUT2_{IC1}: IC1.6 (OUT2), J6.2
OUT2_{IC2}: IC2.6 (OUT2), J6.4
OUT2_{IC3}: IC3.6 (OUT2), J6.6
OUT2_{IC4}: IC4.6 (OUT2), J6.8
OUT2_{IC5}: IC5.6 (OUT2), J6.10
OUT2_{IC6}: IC6.6 (OUT2), J6.12
OUT2_{IC7}: IC7.6 (OUT2), J6.14
OUT2_{IC8}: IC8.6 (OUT2), J6.16
OUT2_{IC9}: IC9.6 (OUT2), J6.18
OUT2_{IC10}: IC10.6 (OUT2), J6.20
OUT2_{IC11}: IC11.6 (OUT2), J6.22
OUT2_{IC12}: IC12.6 (OUT2), J6.24
OUT2_{IC13}: IC13.6 (OUT2), J6.26
OUT2_{IC14}: IC14.6 (OUT2), J6.28
OUT2_{IC15}: IC15.6 (OUT2), J6.30
OUT2_{IC16}: IC16.6 (OUT2), J6.32
RIN1: IC1.5 (RIN), U1.40 (GP38)
RIN2: IC2.5 (RIN), U1.42 (GP40)
RIN3: IC3.5 (RIN), U1.44 (GP42)
RIN4: IC4.5 (RIN), U1.46 (GP44)
RIN5: IC5.5 (RIN), U1.38 (GP36)
RIN6: IC6.5 (RIN), U1.36 (GP34)
RIN7: IC7.5 (RIN), U1.34 (GP32)
RIN8: IC8.5 (RIN), U1.32 (GP31)
RIN9: IC9.5 (RIN), U1.24 (GP23)
RIN10: IC10.5 (RIN), U1.26 (GP25)
RIN11: IC11.5 (RIN), U1.28 (GP27)
RIN12: IC12.5 (RIN), U1.30 (GP29)
RIN13: IC13.5 (RIN), U1.22 (GP21)
RIN14: IC14.5 (RIN), U1.20 (GP19)
RIN15: IC15.5 (RIN), U1.16 (GP16)
RIN16: IC16.5 (RIN), U1.14 (GP14)
RUN: J5.1, U1.56 (RUN)
SWCLK: J3.3, U1.55 (SWCLK)
SWDIO: J3.1, U1.52 (SWDIO)
VBUS: C8.1, C9.1, D1.1 (K), D2.1 (K), U1.60 (VBUS)
VDD: C1.1, C2.1, C5.1, C6.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, IC1.1 (VREF), IC1.7 (VCC), IC2.1 (VREF), IC2.7 (VCC), IC3.1 (VREF), IC3.7 (VCC), IC4.1 (VREF), IC4.7 (VCC), IC5.1 (VREF), IC5.7 (VCC), IC6.1 (VREF), IC6.7 (VCC), IC7.1 (VREF), IC7.7 (VCC), IC8.1 (VREF), IC8.7 (VCC), IC9.1 (VREF), IC9.7 (VCC), IC10.1 (VREF), IC10.7 (VCC), IC11.1 (VREF), IC11.7 (VCC), IC12.1 (VREF), IC12.7 (VCC), IC13.1 (VREF), IC13.7 (VCC), IC14.1 (VREF), IC14.7 (VCC), IC15.1 (VREF), IC15.7 (VCC), IC16.1 (VREF), IC16.7 (VCC), IC17.1 (VIN), J1.2

Notes on the sheet:
INPUT
モータードライバー
マイコン

Board: 2 copper layers, 125.0 x 125.0 mm, 68 parts (1 on the bottom side), 78 nets.

## Commit log

2024-12-25 Create kicad
